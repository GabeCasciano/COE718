# Keil uVision project BitBand.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: BitBand
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group System
    ./: startup_LPC17xx.s
    ../Blinky/: system_LPC17xx.c
  group Src
    ./: bitbandled.c LED.c LED.h
    ../Blinky/: Joystick.c Joystick.h KDB.c KDB.h Font_6x8_h.h Font_16x24_h.h GLCD.h GLCD_SPI_LPC1700.c
