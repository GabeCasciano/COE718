# Keil uVision project L4_p1.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: L4_p1
  c flags: Optim=1
  c include: ..\Lab_4a
  asm include: ..\Lab_4a
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group System
    ./: startup_LPC17xx.s system_LPC17xx.c
  group RTX
    ./: RTX_Conf_CM.c
    C:/Keil/ARM/CMSIS/uVision/LIB/ARM/: RTX_CM3.lib
  group src
    ./: ADC.c GLCD_SPI_LPC1700.c Joystick.c KDB.c LED.c a2.c
