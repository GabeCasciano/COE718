# Keil uVision project Lab3.uvprojx, settings and files
target LPC1768 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\lab3a_1;C:\Keil_v5\ARM\RV31\INC
  asm include: .\lab3a_1;C:\Keil_v5\ARM\RV31\INC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ./lab3a_1/: system_LPC17xx.c
    ./: startup_LPC17xx.s
  group Configuration
    ./lab3a_1/: RTX_Conf_CM.c
  group Source Files
    ./lab3a_1/: Demo.c
software components: CMSIS:CORE 5.3.0
